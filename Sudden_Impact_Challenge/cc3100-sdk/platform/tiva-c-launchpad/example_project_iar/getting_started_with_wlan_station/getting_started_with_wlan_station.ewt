<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>board</name>
    <file>
      <name>$PROJ_DIR$\..\..\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\board.h</name>
    </file>
  </group>
  <group>
    <name>cli_uart</name>
    <file>
      <name>$PROJ_DIR$\..\..\cli_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cli_uart.h</name>
    </file>
  </group>
  <group>
    <name>simplelink</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\device.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\fs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\netapp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\netcfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\simplelink.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\socket.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\trace.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\wlan.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\include\wlan_rx_filters.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\driver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\driver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\flowcont.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\flowcont.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\fs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\netapp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\netcfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\nonos.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\nonos.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\objInclusion.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\protocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\socket.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\spawn.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\spawn.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\simplelink\source\wlan.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\user.h</name>
    </file>
  </group>
  <group>
    <name>spi</name>
    <file>
      <name>$PROJ_DIR$\..\..\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\spi.h</name>
    </file>
  </group>
  <group>
    <name>uart</name>
    <file>
      <name>$PROJ_DIR$\..\..\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\uart.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\examples\getting_started_with_wlan_station\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\startup_ewarm.c</name>
  </file>
</project>


