# IAR project getting_started_with_wlan.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 500
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: _USE_CLI_
  ICC430.newCCIncludePaths: ..\..\; ..\..\..\..\simplelink\include; ..\..\..\..\simplelink\source; ..\..\..\..\examples\common
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../../../../examples/getting_started_with_wlan_station/: main.c
  group board
    ../../: board.c board.h
  group cli_uart
    ../../: cli_uart.c cli_uart.h
  group simplelink
    ../../: user.h
  group simplelink/inc
    ../../../../simplelink/include/: device.h fs.h netapp.h netcfg.h simplelink.h socket.h trace.h wlan.h wlan_rx_filters.h
  group simplelink/src
    ../../../../simplelink/source/: device.c driver.c driver.h flowcont.c flowcont.h fs.c netapp.c netcfg.c nonos.c nonos.h objInclusion.h protocol.h socket.c spawn.c spawn.h wlan.c
  group spi
    ../../: spi.c spi.h
